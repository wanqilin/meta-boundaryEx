SRC_URI = "git://github.com/boundarydevices/isp-vvcam.git;protocol=https;branch=${SRCBRANCH}"
SRCREV = "34c0d13d71dcb8c8091258cc0b81482369b61b82"
SRCBRANCH = "ezurio-lf-6.6.3_1.0.0"
