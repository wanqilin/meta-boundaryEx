RRECOMMENDS:libgal-imx += "kernel-module-imx-gpu-viv"
